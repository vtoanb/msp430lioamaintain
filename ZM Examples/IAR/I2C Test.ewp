# IAR project I2C Test.ewp, settings and files
configuration Launchpad (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 300
  General.GHeapSize2: 30
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: LAUNCHPAD; ADDRESS_SEARCH; TEST_TCS3414; TEST_TMP006; TEST_EEPROM; xEEPROM_VERBOSE
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZM; ../HAL; ../Common
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../: example_I2C_test.c
  group Common
    ../../Common/: printf.c utilities.c
  group HAL
    ../../HAL/: hal_AMS_TCS3414_color_sensor.c hal_bit_bang_i2c.c hal_launchpad.c hal_Microchip_24xxxxx_eeprom.c hal_TI_TMP006_IR_temperature_sensor.c
