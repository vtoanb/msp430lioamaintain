# IAR project Basic Comms - Coordinator - SAPI.ewp, settings and files
configuration Launchpad (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: LAUNCHPAD; xDISPLAY_NETWORK_INFORMATION; ZM_PHY_SPI; REGION_NORTH_AMERICA; VERBOSE_ERROR_HANDLING
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZM; ../HAL; ../Common
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../: example_basic_comms_coordinator_sapi.c module_example_utils.c
  group Common
    ../../Common/: printf.c utilities.c
  group HAL
    ../../HAL/: hal_launchpad.c
  group ZM
    ../../ZM/: application_configuration.c module.c module_errors.c simple_api.c zm_phy_spi.c
