# IAR project Read IR Temperature Sensor.ewp, settings and files
configuration Launchpad (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 200
  General.GHeapSize2: 30
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: LAUNCHPAD
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZM; ../HAL; ../Common
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../: example_read_IR_temperature_sensor.c
  group Common
    ../../Common/: printf.c
  group HAL
    ../../HAL/: hal_bit_bang_i2c.c hal_launchpad.c hal_TI_TMP006_IR_temperature_sensor.c
