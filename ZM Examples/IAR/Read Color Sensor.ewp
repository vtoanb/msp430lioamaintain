# IAR project Read Color Sensor.ewp, settings and files
configuration Launchpad (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: LAUNCHPAD; xTCS3414_VERBOSE
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZM; ../HAL; ../Common
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../: example_read_color_sensor.c
  group Common
    ../../Common/: printf.c
  group HAL
    ../../HAL/: hal_AMS_TCS3414_color_sensor.c hal_bit_bang_i2c.c hal_launchpad.c
